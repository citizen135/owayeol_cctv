Commit message: aa

File: urdf/cctv (사본).urdf (robot description, URDF)
Before this commit: robot cctv, 4 links, 3 joints
Joints:
- joint joint1: origin xyz=0 0 2.012 rpy=0 0 0 -> xyz=0 0 0.012 rpy=0 0 0
